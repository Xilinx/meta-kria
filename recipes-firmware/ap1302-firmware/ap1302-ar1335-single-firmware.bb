SUMMARY = "ap1302 ar1335-single firmware binary"
LICENSE = "Proprietary"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=516345ebfa8b37b17fa2b09c442ca109"

include ap1302-firmware.inc

FW_NAME = "ap1302_ar1335_single_fw.bin"
