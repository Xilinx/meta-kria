SUMMARY = "Firmware for the kv260 dpu benchmark design"

inherit fpgamanager_custom
include kv260-firmware.inc

FW_DIR = "benchmark-b4096"
