SUMMARY = "Firmware for the kv260 defect detection AA4 design"

inherit fpgamanager_custom
include kv260-firmware.inc

FW_DIR = "defect-detect"
