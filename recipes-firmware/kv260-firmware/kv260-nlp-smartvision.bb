SUMMARY = "Firmware for the kv260 nlp-smartvision design"

inherit fpgamanager_custom
include kv260-firmware.inc

FW_DIR = "nlp-smartvision"
