SUMMARY = "Firmware for the kv260 smartcamera AA1 design"

inherit fpgamanager_custom
include kv260-firmware.inc

FW_DIR = "smartcam"
