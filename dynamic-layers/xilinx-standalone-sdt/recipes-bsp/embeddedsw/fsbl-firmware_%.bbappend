XLNX_CMAKE_BSP_VARS:append:kria = " -DFSBL_DEBUG"
