HDF_MACHINE:k26-sm = "k26-som"
HDF_MACHINE:k26-smk = "k26-starterkit"
HDF_MACHINE:k26-kv = "kv260"
HDF_MACHINE:k26-kr = "kr260"
