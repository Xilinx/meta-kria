YAML_SERIAL_CONSOLE_STDIN:k26 ?= "psu_uart_1"
YAML_SERIAL_CONSOLE_STDOUT:k26 ?= "psu_uart_1"
YAML_COMPILER_FLAGS:append:k26 ?= " -DFSBL_DEBUG"
