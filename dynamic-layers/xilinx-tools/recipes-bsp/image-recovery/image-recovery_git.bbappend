COMPATIBLE_MACHINE:zynqmp:kria = "^$"
