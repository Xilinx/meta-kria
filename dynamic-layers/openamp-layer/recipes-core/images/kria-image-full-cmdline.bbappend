IMAGE_INSTALL += " \
    k24-openamp-fw-examples \
    k26-openamp-fw-examples \
    packagegroup-openamp \
"
