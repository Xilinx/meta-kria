#RDEPENDS:${PN}-echo-test:append:k24-kria = " openamp-fw-echo-testd"
#RDEPENDS:${PN}-echo-test:append:k26-kria = " openamp-fw-echo-testd"

#RDEPENDS:${PN}-matrix-mul:append:k24-kria = " openamp-fw-mat-muld"
#RDEPENDS:${PN}-matrix-mul:append:k26-kria = " openamp-fw-mat-muld"

#RDEPENDS:${PN}-rpc-demo:append:k24-kria = " openamp-fw-rpc-demo"
#RDEPENDS:${PN}-rpc-demo:append:k26-kria = " openamp-fw-rpc-demo"
