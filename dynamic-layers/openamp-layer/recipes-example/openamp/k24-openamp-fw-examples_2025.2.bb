SUMMARY = "OpenAMP firmware examples demo payload processing"
DESCRIPTION = "OpenAMP firmware examples demo payload processing"
LICENSE = "CLOSED"

SRC_URI = "https://edf.amd.com/sswreleases/rel-v2025.2/edf_files/2025.2/11100846/external/packagegroup-openamp-fw-examples/k24-smk-sdt_packagegroup-openamp-fw-examples_11100846.tar.gz"
SRC_URI[sha256sum] = "649d63359d674922438c1a5913def5b94a950f9ad210ee1f652c8e2a484ae46e"

require conf/includes/openamp-fw-example.inc
