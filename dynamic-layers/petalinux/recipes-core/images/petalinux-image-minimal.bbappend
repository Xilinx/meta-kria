require petalinux-image-common-som.inc
