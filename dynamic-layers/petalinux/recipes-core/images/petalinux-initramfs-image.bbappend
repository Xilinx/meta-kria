INITRAMFS_PACKAGES:append:kria = "mac-config"
