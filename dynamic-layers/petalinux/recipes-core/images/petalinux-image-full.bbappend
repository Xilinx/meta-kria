require petalinux-image-common-kria.inc
