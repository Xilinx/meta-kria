XLNX_CMAKE_BSP_VARS:append:k26-kria = " -DK26_SOM"
XLNX_CMAKE_BSP_VARS:append:k24-kria = " -DK24_SOM"
