HDF_MACHINE:k26-som = "k26-som"
