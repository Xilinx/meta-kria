BOOTBIN_INCLUDE:kria = "xilinx-bootbin-kria.inc"

include ${BOOTBIN_INCLUDE}
