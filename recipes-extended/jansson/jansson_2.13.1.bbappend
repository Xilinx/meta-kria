SRCREV = "ca80d5127e56dd2ee056fdf3f4204017b78b89e0"
PV = "2.13.1+git${SRCPV}"

SRC_URI = "git://github.com/akheron/jansson.git;branch=master;protocol=http"

S = "${WORKDIR}/git"
