INITRAMFS_PACKAGES:append:kv260-starter-kit = "som-carrier-autoload misc-config"
