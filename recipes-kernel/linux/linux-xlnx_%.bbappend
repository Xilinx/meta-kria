KERNEL_MODULE_AUTOLOAD:kria += "usb5744"

# Temporary branch and srcrev update
KBRANCH = "xlnx_rebase_v6.1_LTS_update"
SRCREV = "1be25baa39da76bec06f5d2fe1463b31d368e843"
