KERNEL_MODULE_AUTOLOAD:kria += "usb5744"
KERNEL_MODULE_AUTOLOAD:kria += "usb2244"

